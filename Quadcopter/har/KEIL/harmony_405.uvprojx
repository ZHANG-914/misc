# Keil uVision project harmony_405.uvprojx, settings and files
target fs (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: harmony_405
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F401xx
  c include: ..\APP\APP_HEAD;..\BASIC\BASIC_HEAD;..\LIB\inc;..\SYS\inc;..\UCOS_PORT;..\UCOS_SOURCE;..\pidcontrol
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CORE
    ../UCOS_SOURCE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group PORT
    ../UCOS_PORT/: os_cpu_c.c os_dbg.c os_cpu_a.s
  group BASIC
    ../BASIC/: GY86.c i2c.c pwm.c usart.c
  group SYS
    ../SYS/src/: startup_stm32f401xx.s stm32f4xx_it.c system_stm32f4xx.c
  group APP
    ../APP/: ANO_DT.c BSP.c main.c BLUETOOTH.c
  group CONFIG
    ../APP/APP_HEAD/: includes.h os_cfg.h app_cfg.h
  group STLIB
    ../LIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group PID
    ../pidcontrol/: control.c filter.c imu.c maths.c pid.c pid_para.c
